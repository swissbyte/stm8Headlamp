# IAR project stm8HeadLamp.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003; __IAR__
  ICCSTM8.CCIncludePath2: C:\code\stm8s\HeadLamp\STM8S_StdPeriph_Lib\Libraries\STM8S_StdPeriph_Driver\inc; C:\code\stm8s\HeadLamp\STM8S_StdPeriph_Lib\Libraries\STM8S_StdPeriph_Driver\src; C:\code\stm8s\HeadLamp\IAR
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8HeadLamp.srec
  ILINK.IlinkOutputFile: stm8HeadLamp.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
    ../STM8S_StdPeriph_Lib/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_exti.c stm8s_gpio.c stm8s_tim1.c
